## arch/arm64/hotplug/Kconfig
```kconfig
config LAZYPLUG
	bool "LazyPlug Hotplug, developed by arter97"
	help
		Based on Intelliplug
```
